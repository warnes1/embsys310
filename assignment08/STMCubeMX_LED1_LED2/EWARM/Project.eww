<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STMCubeMX_LED1_LED2.ewp</path>
  </project>
  <batchBuild />
</workspace>
